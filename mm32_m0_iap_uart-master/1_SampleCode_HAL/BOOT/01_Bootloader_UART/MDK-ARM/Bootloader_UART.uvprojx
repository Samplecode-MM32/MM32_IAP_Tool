# Keil uVision project Bootloader_UART.uvprojx, settings and files
target MM32F031CBT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031CBT MindMotion
  pack: MindMotion.MM32F031_DFP.1.3.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32F031_N_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32F031_N
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32F031xx_n\HAL_lib\inc;..\..\..\..\3_Device\MM32F031xx_n\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32F031_N
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000b4 size 0x1f4c
  group STARTUP
    ../../../../3_Device/MM32F031xx_n/Source/: system_MM32F031xxn.c
    ../../../../3_Device/MM32F031xx_n/Source/KEIL_StartAsm/: startup_BOOT_MM32F031xxn_KEIL.s
    ../../../../3_Device/MM32L0xx_n/Source/: system_MM32L0xx.c
    ../../../../3_Device/MM32L0xx_n/Source/KEIL_StartAsm/: startup_BOOT_MM32L0xx.s
    ../../../../3_Device/MM32SPIN2xx_p/Source/: system_MM32SPIN2xx_p.c
    ../../../../3_Device/MM32SPIN2xx_p/Source/KEIL_StartAsm/: startup_BOOT_MM32SPIN2xx_p.s
    ../../../../3_Device/MM32F031xx_q/Source/: system_MM32F031x4x6_q.c
    ../../../../3_Device/MM32F031xx_q/Source/KEIL_StartAsm/: startup_BOOT_MM32F031x4x6_q.s
    ../../../../3_Device/MM32SPIN0x_q/Source/: system_MM32SPIN0x_q.c
    ../../../../3_Device/MM32SPIN0x_q/Source/KEIL_StartAsm/: startup_BOOT_MM32SPIN0x_q.s
    ../../../../3_Device/MM32F003_q/Source/: system_MM32F003_q.c
    ../../../../3_Device/MM32F003_q/Source/KEIL_StartAsm/: startup_BOOT_MM32F003_q.s
    ../../../../3_Device/MM32F032xx_s/Source/: system_MM32F032xx_s.c
    ../../../../3_Device/MM32F032xx_s/Source/KEIL_StartAsm/: startup_BOOT_MM32F032xx_s_KEIL.s
    ../../../../3_Device/MM32L06xx_s/Source/: system_mm32l06xx_s.c
    ../../../../3_Device/MM32L06xx_s/Source/KEIL_StartAsm/: startup_BOOT_MM32L06xx_s_keil.s
    ../../../../3_Device/MM32SPIN06xx_s/Source/: system_mm32spin06xx_s.c
    ../../../../3_Device/MM32SPIN06xx_s/Source/KEIL_StartAsm/: startup_BOOT_MM32SPIN06xx_s_keil.s
  group HAL_LIB_MM32F031_N
    ../../../../3_Device/MM32F031xx_n/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL_LIB_MM32L0XX_N
    ../../../../3_Device/MM32L0xx_n/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL_LIB_MM32SPIN2X_P
    ../../../../3_Device/MM32SPIN2xx_p/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL_LIB_MM32F031_Q
    ../../../../3_Device/MM32F031xx_q/HAL_lib/src/: HAL_adc.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL_LIB_MM32SPIN05_Q
    ../../../../3_Device/MM32SPIN0x_q/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL_LIB_MM32F003_Q
    ../../../../3_Device/MM32F003_q/HAL_lib/src/: HAL_adc.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL_LIB_MM32F032_S
    ../../../../3_Device/MM32F032xx_s/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_crc.c HAL_dbg.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_ver.c HAL_wwdg.c
  group HAL_LIB_MM32L0XX_S
    ../../../../3_Device/MM32L06xx_s/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group HAL_LIB_MM32SPIN06_S
    ../../../../3_Device/MM32SPIN06xx_s/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group APP
    ../APP/: main.c m0_isr_redefine.c xmodem.c ymodem.c binary.c ascii.c
  group TOOL
    ../TOOL/: check.c queue.c
  group Peripheral
    ../Peripheral/: uart.c tim3.c flash.c
  group README
    ../: readme.txt
target MM32L073PF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: as above
  output: MM32L073_N_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32L0XX_N
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32L0xx_n\HAL_lib\inc;..\..\..\..\3_Device\MM32L0xx_n\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32L0XX_N
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000c0 size 0x1f40
target MM32SPIN27PF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN27PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.1
  cpu: as above
  output: MM32SPIN27_P_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32SPIN27_P
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32SPIN2xx_p\HAL_lib\inc;..\..\..\..\3_Device\MM32SPIN2xx_p\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32SPIN27_P
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000c0 size 0x1f4c
target MM32F031C6T6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.3.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32F031_Q_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32F031_Q
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32F031xx_q\HAL_lib\inc;..\..\..\..\3_Device\MM32F031xx_q\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32F031_Q
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000b4 size 0xf4c
target MM32SPIN05PF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.4
  cpu: as above
  output: MM32SPIN05_Q_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32SPIN05_Q
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32SPIN0x_q\HAL_lib\inc;..\..\..\..\3_Device\MM32SPIN0x_q\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32SPIN05_Q
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000b4 size 0xf4c
target MM32F003TW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F003TW MindMotion
  pack: MindMotion.MM32F003_DFP.1.0.3
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32F003_Q_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32F003_Q
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32F003_q\HAL_lib\inc;..\..\..\..\3_Device\MM32F003_q\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32F003_Q
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000b4 size 0x74c
target MM32F032R8T6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F032R8T6 MindMotion
  pack: MindMotion.MM32F032_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32F032_S_BOOT_XMODEM +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32F032_S
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32F032xx_s\HAL_lib\inc;..\..\..\..\3_Device\MM32F032xx_s\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000c0 size 0x3f40
target MM32L062PF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L062PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MM32L062_S_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32L06XX_S
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32L06xx_s\HAL_lib\inc;..\..\..\..\3_Device\MM32L06xx_s\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32L06XX_S
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000c0 size 0x3f40
target MM32SPIN06PF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN06PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.4
  cpu: as above
  output: MM32SPIN06_S_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32SPIN06XX_S
  c include: ..\..\..\..\3_Device\CMSIS\KEIL_CORE;..\..\..\..\3_Device\MM32SPIN06xx_s\HAL_lib\inc;..\..\..\..\3_Device\MM32SPIN06xx_s\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32SPIN06XX_S
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1400
  memory RVCT9: RAM 0x200000c0 size 0x3f40
