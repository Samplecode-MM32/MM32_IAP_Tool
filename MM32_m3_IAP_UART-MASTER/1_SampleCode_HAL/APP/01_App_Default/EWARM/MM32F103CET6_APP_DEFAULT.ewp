# IAR project MM32F103CET6_APP_DEFAULT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F103CET MindMotion MM32F103CET
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; MM32F103xCxE_O; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\2_Device\CMSIS\IAR_CORE; ..\..\..\..\2_Device\MM32F103xCxE_o\HAL_lib\inc; ..\..\..\..\2_Device\MM32F103xCxE_o\Include; ..\Peripheral\inc; ..\BSP\inc; ..\APP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MM32F103xCxE_O
  AARM.AUserIncludes: ..\APP\inc
  OBJCOPY.OOCOutputFile: MM32F103CET6_APP_DEFAULT.bin
  ILINK.IlinkOutputFile: MM32F103_O_APP_DEFAULT.out
  ILINK.IlinkIcfFile: C:\Users\yang3\Desktop\ISP_UART\MM32_M3_IAP_UART\1_SampleCode_HAL\APP\01_App_Default\APP\MM32f103xE_APP_Default.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: main.c
  group BSP
    ../BSP/: bsp_led.c
  group HAL_LIB
    ../../../../2_Device/MM32F103xCxE_o/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group Peripheral
    ../Peripheral/: flash.c systick.c tim1.c uart.c
  group README
    ../: readme.txt
  group STARTUP
    ../../../../2_Device/MM32F103xCxE_o/Source/IAR_StartAsm/: startup_MM32F103xCxE_o.s
    ../../../../2_Device/MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
