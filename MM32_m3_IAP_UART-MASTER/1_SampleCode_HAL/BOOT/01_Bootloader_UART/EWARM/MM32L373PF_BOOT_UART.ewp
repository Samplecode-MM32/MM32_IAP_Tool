# IAR project MM32L373PF_BOOT_UART.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L373PF MindMotion MM32L373PF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR; MM32L3XX_N; USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\2_Device\CMSIS\IAR_CORE; ..\..\..\..\2_Device\MM32L3xx_n\HAL_lib\inc; ..\..\..\..\2_Device\MM32L3xx_n\Include; ..\Peripheral\inc; ..\TOOL\inc; ..\APP\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MM32L3XX_N
  AARM.AUserIncludes: ..\APP\inc
  OBJCOPY.OOCOutputFile: MM32L373PF_BOOT_UART.hex
  ILINK.IlinkOutputFile: MM32L373PF_BOOT_UART.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\MindMotion\MM32L37xxx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: ascii.c binary.c main.c xmodem.c ymodem.c
  group HAL_LIB
    ../../../../2_Device/MM32L3xx_n/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group Peripheral
    ../Peripheral/: flash.c tim3.c uart.c
  group README
    ../: readme.txt
  group STARTUP
    ../../../../2_Device/MM32L3xx_n/Source/IAR_StartAsm/: startup_MM32L3xx.s
    ../../../../2_Device/MM32L3xx_n/Source/: system_MM32L3xx.c
  group TOOL
    ../TOOL/: check.c queue.c
