# Keil uVision project Bootloader_UART.uvprojx, settings and files
target MM32L373PF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32L373_N_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32L3XX_N
  c include: ..\..\..\..\2_Device\CMSIS\KEIL_CORE;..\..\..\..\2_Device\MM32L3xx_n\HAL_lib\inc;..\..\..\..\2_Device\MM32L3xx_n\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32L3XX_N
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2800
  memory RVCT9: RAM 0x200000f8 size 0x4f08
  group STARTUP
    ../../../../2_Device/MM32L3xx_n/Source/: system_MM32L3xx.c
    ../../../../2_Device/MM32L3xx_n/Source/KEIL_StartAsm/: startup_MM32L3xx.s
    ../../../../2_Device/MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
    ../../../../2_Device/MM32F103xCxE_o/Source/KEIL_StartAsm/: startup_MM32F103xCxE_o.s
  group HAL_LIB_MM32L3xx_N
    ../../../../2_Device/MM32L3xx_n/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HAL_LIB_MM32F103xCxE_O
    ../../../../2_Device/MM32F103xCxE_o/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group APP
    ../APP/: main.c xmodem.c ymodem.c binary.c ascii.c
  group TOOL
    ../TOOL/: check.c queue.c
  group Peripheral
    ../Peripheral/: uart.c tim3.c flash.c
  group README
    ../: readme.txt
target MM32F103CET6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F103CET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32F103_O_BOOT_UART +hex
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER  MM32F103xCxE_O
  c include: ..\..\..\..\2_Device\CMSIS\KEIL_CORE;..\..\..\..\2_Device\MM32F103xCxE_o\HAL_lib\inc;..\..\..\..\2_Device\MM32F103xCxE_o\Include;..\Peripheral\inc;..\TOOL\inc;..\APP\inc
  asm define: MM32F103xCxE_O
  asm misc: --cpreproc
  asm include: ..\APP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2800
  memory RVCT9: RAM 0x200001b4 size 0x1fe4c
